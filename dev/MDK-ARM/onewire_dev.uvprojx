# Keil uVision project onewire_dev.uvprojx, settings and files
target OneWire DEV (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L496ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f4_usart_onewire
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32L496xx
  c include: ..\inc;..\..\src\include;..\..\libs\st_hal\STM32L4xx_HAL_Driver\Inc;..\..\libs\st_hal\CMSIS\Include;..\..\libs\st_hal\CMSIS\Device\ST\STM32L4xx\Include;..\..\libs\FreeRTOS\include;..\..\libs\FreeRTOS\CMSIS_RTOS;..\..\libs\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ./: startup_stm32l496xx.s
  group CMSIS
    ../src/: system_stm32l4xx.c
  group STM32L4xx_HAL_Driver
    ../../libs/st_hal/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_dma.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c
  group FreeRTOS
    ../../libs/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../libs/FreeRTOS/CMSIS_RTOS/: cmsis_os.c cpu_utils.c
    ../../libs/FreeRTOS/portable/RVDS/ARM_CM4F/: port_cm4.c
    ../../libs/FreeRTOS/portable/MemMang/: heap_4.c
  group OneWire
    ../../src/ow/: ow.c
    ../../src/system/: ow_ll_stm32l4.c ow_sys_cmsis_os.c
  group User
    ../src/: stm32l4xx_it.c
    ../Src/: main.c
software components: CMSIS:CORE 5.0.2
